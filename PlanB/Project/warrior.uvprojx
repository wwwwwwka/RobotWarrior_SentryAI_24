# Keil uVision project warrior.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: warrior
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\Startup;..\User;..\User\hardware;..\User\AHRS;..\User\Components\algorithm;..\User\Components\algorithm\Include;..\User\Components\controller;..\User\Components\devices;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\User\APP\FreeRTOS;..\User\user_lib;..\User\APP\INS_task;..\User\APP\user_task;..\User\APP\CAN_receive;..\User\APP\remote_control;..\User\APP\gimbal_task;..\User\APP\calibrate_task;..\User\APP\shoot;..\User\APP\voltage_task;..\User\APP\ROS_Receive;..\User\APP\chassis_task;..\User\APP\referee_task;..\User\Components\support;..\User\APP\detect_task;..\User\hardware\bsp_dwt;..\User\hardware\timer;..\User\APP\UI_task
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../User/hardware/: flash.c
  group Hardware
    ../User/hardware/: led.c rc.c uart1.c can.c i2c.c buzzer.c key.c spi.c trigger.c exit.c temperature.c delay.c sys.c adc.c bluetooth.c referee_usart.c laser.c camera_trigger.c
    ../User/hardware/bsp_dwt/: dwt.c
    ../User/hardware/timer/: timer.c
  group APP
    ../User/APP/FreeRTOS/: FreeRTOS_middleware.c start_task.c
    ../User/APP/INS_task/: INS_task.c
    ../User/APP/user_task/: user_task.c
    ../User/APP/CAN_receive/: CAN_receive.c
    ../User/APP/remote_control/: remote_control.c rc_handoff.c
    ../User/APP/gimbal_task/: gimbal_behaviour.c gimbal_task.c
    ../User/APP/calibrate_task/: calibrate_task.c
    ../User/APP/shoot/: shoot.c
    ../User/APP/voltage_task/: voltage_task.c
    ../User/APP/ROS_Receive/: ROS_Receive.c
    ../User/APP/chassis_task/: chassis_behaviour.c chassis_task.c chassis_power_control.c
    ../User/APP/referee_task/: referee.c referee_usart_task.c
    ../User/APP/detect_task/: detect_task.c
  group controller
    ../User/Components/controller/: pid.c
  group devices
    ../User/Components/devices/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group algorithm
    ../User/Components/algorithm/: AHRS.lib AHRS_middleware.c arm_cortexM4lf_math.lib
  group user_lib
    ../User/user_lib/: user_lib.c Kalman_Filter.c
  group USER
    ../User/: main.c main.h
  group support
    ../User/Components/support/: CRC8_CRC16.c fifo.c mem_mang4.c
